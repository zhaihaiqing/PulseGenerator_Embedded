# Keil uVision project Project.uvprojx, settings and files
target STM32F4XX (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4_DEMO +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: .\CMSIS;.\FWlib\inc;.\FWlib\src;.\User;.\User\SYSTEM;.\User\HARDWARE\ADC;.\User\HARDWARE\AT24C64;.\User\HARDWARE\BEEP;.\User\HARDWARE\CODEC;.\User\HARDWARE\CRC;.\User\HARDWARE\DAC;.\User\HARDWARE\INPUT;.\User\HARDWARE\KEY;.\User\HARDWARE\LED;.\User\HARDWARE\MALLOC;.\User\HARDWARE\MANUAL;.\User\HARDWARE\OUTPUT;.\User\HARDWARE\PROTOCOL;.\User\HARDWARE\PULSE;.\User\HARDWARE\PULSETRAN;.\User\HARDWARE\PWM;.\User\HARDWARE\SSD1961;.\User\HARDWARE\SWITCH;.\User\HARDWARE\TIMER;.\User\HARDWARE\UI;.\User\HARDWARE\USART;.\User\HARDWARE\WDG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: main.c stm32f4xx_it.c
  group Hardware
    ./User/HARDWARE/MANUAL/: Manual.c
    ./User/HARDWARE/SWITCH/: Switch.c
    ./User/HARDWARE/OUTPUT/: Output.c
    ./User/HARDWARE/INPUT/: Trigger.c
    ./User/HARDWARE/AT24C64/: AT24C64MemData.c AT24C64IIC.c AT24C64.c
    ./User/HARDWARE/PULSE/: Pulse.c
    ./User/HARDWARE/PULSETRAN/: PulseTran.c
    ./User/HARDWARE/UI/: UI.c
    ./User/HARDWARE/TIMER/: Timer.c Timer6.c
    ./User/HARDWARE/LED/: Led.c
    ./User/HARDWARE/BEEP/: Beep.c
    ./User/HARDWARE/DAC/: DAC.c
    ./User/HARDWARE/KEY/: Key.c
    ./User/HARDWARE/CODEC/: Codec.c
    ./User/HARDWARE/USART/: Usart1.c
    ./User/HARDWARE/MALLOC/: Malloc.c
    ./User/HARDWARE/CRC/: Crc.c
    ./User/HARDWARE/PROTOCOL/: Protocol.c
    ./User/HARDWARE/SSD1961/: SSD1961.c
    ./User/HARDWARE/WDG/: Wdg.c
  group System
    ./User/SYSTEM/: delay.c sys.c debug_uart.c
  group StdPeriph_Driver
    ./FWlib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CMSIS
    ./User/: system_stm32f4xx.c
  group MDK-ARM
    ./CMSIS/startup/arm/: startup_stm32f40_41xxx.s
